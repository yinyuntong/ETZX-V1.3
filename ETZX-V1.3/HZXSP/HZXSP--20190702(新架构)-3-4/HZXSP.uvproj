# Keil uVision project HZXSP.uvproj, settings and files
target KTKZQ (ARM-ADS)
  device: LPC1114x301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: HZXSP +hex
  c flags: Optim=4 oTime=1
  c include: .\CM0;.\LPC11xx;.\USER_CODE
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group CM0
    ./CM0/: core_cm0.c
    ./LPC11xx/: system_LPC11xx.c
    ./LPC11xx/startup/: startup_LPC11xx.s
  group USER
    ./USER_CODE/: E2PROM.c main.c SPI.c util.c LED.C SingleBus.c uart.c CC1101.c
