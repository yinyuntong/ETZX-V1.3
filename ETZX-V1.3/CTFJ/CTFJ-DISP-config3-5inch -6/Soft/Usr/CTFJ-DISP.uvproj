# Keil uVision project CTFJ-DISP.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ STC
  cpu: IRAM(0 - 0xFF) XRAM(0- 0x3FF) IROM(0 - 0x7FFF) CLOCK(25000000)
  output: CTFJ-DISP-V4-6 +hex
  c flags: Optimize=8 SizeSpeed=1
  group usr
    ./: EPH1660.C GT23.C IAP.c LCD.c main.c parameter.c SingleBus.c SPI.C Uart.c PCT25VF.C 128x80shenti.C
  group os
    ../OS/: OS_CORE.C OS_MEM.C OS_Q.C OS_SEM.C
  group target
    ../Target/: OS_CPU_C.C OS_CPU_A.ASM
