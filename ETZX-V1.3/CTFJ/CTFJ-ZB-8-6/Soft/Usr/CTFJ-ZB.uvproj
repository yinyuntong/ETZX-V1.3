# Keil uVision project CTFJ-ZB.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ STC
  cpu: IRAM(0 - 0xFF) XRAM(0- 0x3FF) IROM(0 - 0x7FFF) CLOCK(25000000)
  output: CTFJ-ZB-V10 +hex
  c flags: Optimize=8 SizeSpeed=1
  group usr
    ./: IAP.c Key.c main.c parameter.c SingleBus.c
  group os
    ../OS/: OS_CORE.C OS_MEM.C OS_Q.C OS_SEM.C
  group target
    ../Target/: OS_CPU_C.C OS_CPU_A.ASM
