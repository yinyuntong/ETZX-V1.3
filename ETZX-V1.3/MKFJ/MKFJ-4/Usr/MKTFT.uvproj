# Keil uVision project MKTFT.uvproj, settings and files
target 门口分机显示 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: MKTFT +hex
  c flags: Optimize=8
  group Usr
    ./: Key.c IAP.c LcdDriver.c main.c SingleBus.c SPI.c uart.c Data.asm
