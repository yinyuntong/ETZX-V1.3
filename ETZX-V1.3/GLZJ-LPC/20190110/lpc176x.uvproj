# Keil uVision project lpc176x.uvproj, settings and files
target boot_flash (ARM-ADS)
  device: LPC1765 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: GLZJ_LPC1765_190110 +hex
  c flags: Optim=1 OneElfS=1
  c misc: --gnu
  c include: .\LPC17xx;.\source;.\startup
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\output\boot_flash\boot_flash.sct
  group startup files
    ./startup/: core_cm3.c startup_LPC17xx.s
    ./LPC17xx/: system_LPC17xx.c
  group source files
    ./source/: main.c Inflash.c uart.c global.c wdt.c voice_play.c interrupt.c timer.c extint.c SingleBus.c tel.c ds3231.c PCT25VF.C wpa_cli.c fm62429.c
  group documention
    ./output/boot_ram/list/: boot_ram.map
