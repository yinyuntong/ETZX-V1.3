# Keil uVision project GLZJ.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ STC
  cpu: IRAM(0 - 0xFF) XRAM(0- 0x3FF) IROM(0 - 0x7FFF) CLOCK(25000000)
  output: GLZJ-V10 +hex
  c flags: Optimize=8 SizeSpeed=1
  group usr
    ./: I2C.c main.c PCF8563.c SingleBus.c Uart.c Key.c IAP.c
