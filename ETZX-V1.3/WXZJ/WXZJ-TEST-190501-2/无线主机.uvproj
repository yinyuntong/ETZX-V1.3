# Keil uVision project 无线主机.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: 无线主机 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: CC1101.c CC1101.h stc12c5624.h 无线主机.c 单总线接口.c 单总线接口.h uart.c uart.h
    ../加床分机/: STARTUP.A51
